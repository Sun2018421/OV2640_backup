# Keil uVision project CAMERA.uvprojx, settings and files
target CAMERA (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.13.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: CAMERA +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F767xx,USE_HAL_DRIVER
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F7xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\SDRAM;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SDMMC;..\HARDWARE\NAND;..\HARDWARE\QSPI;..\HARDWARE\W25QXX;..\HARDWARE\DCMI;..\HARDWARE\OV2640;..\HARDWARE\PCF8574;..\HARDWARE\TIMER;..\HARDWARE\MPU;..\USMART;..\MALLOC;..\FATFS\exfuns;..\FATFS\src;..\TEXT;..\PICTURE;..\X-CUBE-AI\App;..\Middlewares\ST\AI\Inc;..\X-CUBE-AI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f7xx_it.c system_stm32f7xx.c
  group CORE
    ../CORE/: core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f767xx.s
  group HALLIB
    ../HALLIB/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sram.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_sd.c stm32f7xx_hal_nand.c stm32f7xx_hal_qspi.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/LCD/: lcd.c ltdc.c
    ../HARDWARE/NAND/: ftl.c nand.c nandtester.c
    ../HARDWARE/SDMMC/: sdmmc_sdcard.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/QSPI/: qspi.c
    ../HARDWARE/DCMI/: dcmi.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/PCF8574/: pcf8574.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MPU/: mpu.c
    ../HARDWARE/OV2640/: ov2640.c sccb.c
  group USMART
    ../USMART/: usmart.c usmart_str.c usmart_config.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/src/: ff.c diskio.c
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group TEXT
    ../TEXT/: text.c fontupd.c
  group PICTURE
    ../PICTURE/: gif.c bmp.c piclib.c tjpgd.c
  group README
    ../: readme.txt
  group Lib
    ../Middlewares/ST/AI/Lib/: NetworkRuntime520_CM7_Keil.lib
  group App
    ../X-CUBE-AI/App/: app_x-cube-ai.c network.c network_data.c
